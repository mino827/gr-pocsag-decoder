options:
  parameters:
    generate_options: qt_gui
    id: pocsag_demod
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 157.953e6
  states: {}
- name: center_freq_2
  id: variable
  parameters:
    value: 157.953e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 4.5e3
  states: {}
- name: ip_addr
  id: variable
  parameters:
    value: '"127.0.0.1"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: symbol_rate_2
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: udp_port
  id: variable
  parameters:
    value: '5125'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz/8.0)
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1472'
    type: byte
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: ip_addr
    port: udp_port
    psize: '1472'
    type: byte
    vlen: '1472'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.1'
    gain_omega: '0.01'
    mu: '0'
    omega: samp_rate/(decimation*symbol_rate)*(1+0.0)
    omega_relative_limit: '0.01'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(5, samp_rate, fsk_deviation_hz,fsk_deviation_hz*2)
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '45'
    samp_rate: samp_rate/decimation
    sym_rate: symbol_rate
    type: fir_filter_fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    bw0: samp_rate/2
    clock_source0: internal
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_udp_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_stream_to_vector_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [root_raised_cosine_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
